# Keil uVision project ROBOCON.uvprojx, settings and files
target ROBOCON (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ROBOCON +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED = 1,ARM_MATH_CM4
  c include: ..\User;..\Library\inc;..\Startup;..\Basic;..\Project;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\BSP;..\Algorithms;..\Devices;..\Apps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
    ../User/: system_stm32f4xx.c
  group FreeRTOS_port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c MyTasks.c MyTasks.h FreeRTOS_Init.c FreeRTOS_Init.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group BSP
    ../BSP/: base.c base.h delay.c delay.h bsp_can.c bsp_can.h sys.c sys.h bsp_usart.c bsp_usart.h bsp_key.c bsp_key.h
  group Algorithms
    ../Algorithms/: math_utils.c math_utils.h PID.c PID.h
  group Devices
    ../Devices/: X_V2.c X_V2.h crsf_protocol.c crsf_protocol.h elrs_Remote.c elrs_Remote.h imu.c imu.h wit_c_sdk.c wit_c_sdk.h REG.h servo.c servo.h tjc_screen.c tjc_screen.h Serial.c Serial.h
  group User
    ../User/: stm32f4xx_it.c stm32f4xx_conf.h main.c Interrupt_Priority.h car_config.h
  group Apps
    ../Apps/: app_chassis.c app_chassis.h app_tower.c app_tower.h app_nav.c app_nav.h app_kin.c app_kin.h app_mission.c app_mission.h
